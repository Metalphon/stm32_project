# Keil uVision project Template.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\LED;.\Public;.\APP\BEEP;.\APP\EXTI;.\APP\SYSTEM;.\APP\USART3;.\APP\TIME4;.\APP\PWM;.\APP\L298N;.\APP\LCD;.\APP\OV2640;.\APP\DCMI;.\APP\USART4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_dcmi.c stm32f4xx_dma.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group APP
    ./APP/LED/: led.c led.h
    ./APP/BEEP/: beep.c
    ./APP/EXTI/: exti.c
    ./APP/SYSTEM/: system.c
    ./APP/USART3/: usart3.c
    ./APP/OV2640/: ov2640.c sccb.c
    ./APP/TIME4/: time4.c
    ./APP/PWM/: pwm.c
    ./APP/L298N/: l298n.c
    ./APP/LCD/: lcd.c
    ./APP/DCMI/: dcmi.c
    ./APP/USART4/: usart4.c
  group Public
    ./Public/: SysTick.c
